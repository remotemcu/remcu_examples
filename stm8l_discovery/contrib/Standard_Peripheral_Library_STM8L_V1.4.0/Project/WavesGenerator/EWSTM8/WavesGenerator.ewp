# IAR project WavesGenerator.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..; ..\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: WavesGenerator.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L15X_MD; NDEBUG
  group STM8L15x_StdPeriph_Driver/src
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_tim4.c stm8l15x_usart.c
  group User/src
    ../src/: delay.c main.c stm8l-discoveryl.c stm8l15x_it.c stm8l_discovery_lcd.c
