# IAR project Project.ewp, settings and files
configuration STM32F10X_XL_BANK1 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL; BOOT_FROM_BANK1
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: STM32F10X_XL_BANK1.out
  ILINK.IlinkIcfFile: stm32f10x_flash_xl_bank1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F10X_XL_BANK2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL; BOOT_FROM_BANK2
  ILINK.IlinkOutputFile: STM32F10X_XL_BANK2.out
  ILINK.IlinkIcfFile: stm32f10x_flash_xl_bank2.icf
  group CMSIS
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../../../Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ../: main.c stm32f10x_it.c
